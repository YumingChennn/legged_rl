Commit message: update biped

File: legged_gym/resources/robots/bipedal/urdf/quick_bipedal.urdf (robot description, URDF)
Before this commit: robot quick_bipedal_urdf, 10 links, 9 joints
Joints:
- joint L_wheel_joint: type revolute -> continuous
- joint R_wheel_joint: type revolute -> continuous
